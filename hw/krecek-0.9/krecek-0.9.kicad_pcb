File: hw/krecek-0.9/krecek-0.9.kicad_pcb (KiCad board)
At the start: 4 copper layers, 177.8 x 88.9 mm, 176 parts, among them CN1 PJ-313B6-B, J1 DAP, J2 AUX, J3 USB_C_Receptacle_USB2.0, J4 U.FL, J5 Micro_SD_Card_Det1, Q1 AO3401A, Q2 AO3401A, Q3 AO3400A, Q4 AO3400A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

Commit message: Fix OFF issues, rename buttons
Resolves #4.
Parts:
- removed JP1: Jumper, Jumper:SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
- removed U7: BQ24045DSQR, LCSC:WSON-10_L2.0-W2.0-P0.40-BL-EP
Connections:
- C29 pad 1: Net-(JP1-B) -> VBUS
- C73 pad 1: /Inputs/BTN_{X} -> /Inputs/BTN_{Y}
- C74 pad 1: /Inputs/BTN_{B} -> /Inputs/BTN_{X}
- C75 pad 1: /Inputs/BTN_{Y} -> /Inputs/BTN_{B}
- J3 pad A6: /Power/USB- -> /Power/USB+
- J3 pad A7: /Power/USB+ -> /Power/USB-
- J3 pad B6: /Power/USB- -> /Power/USB+
- J3 pad B7: /Power/USB+ -> /Power/USB-
- SW4 pad 2: /Inputs/BTN_{B} -> /Inputs/BTN_{X}
- SW4 pad 3: /Inputs/BTN_{X} -> /Inputs/BTN_{Y}
- SW4 pad 4: /Inputs/BTN_{Y} -> /Inputs/BTN_{B}
- U3 pad 28: /Inputs/VOL_{SW} -> /Power/OFF
- U3 pad 35: /Inputs/BTN_{B} -> /Inputs/BTN_{X}
- U3 pad 36: /Inputs/BTN_{Y} -> /Inputs/BTN_{B}
- U3 pad 37: /Inputs/BTN_{X} -> /Inputs/BTN_{Y}
- U3 pad 52: /Power/OFF -> Net-(U3-QSPI_SCLK)
- U3 pad 56: unconnected-(U3-QSPI_SS-Pad56) -> Net-(U3-QSPI_SS)
Routing:
- net /Inputs/BTN_{Y}: track 108.5 -> 0.00 mm, vias 2 -> 0
- net /Inputs/BTN_{B}: track 73.4 -> 181.9 mm, vias 2 -> 4
- net VBUS: track 144.2 -> 246.3 mm, vias 6 -> 10
- net Net-(JP1-B): track 102.1 -> 0.00 mm, vias 4 -> 0
- added copper zone on F.Cu, net VBUS
- removed copper zone on F.Cu, net Net-(JP1-B)

Commit message: Improve flip-flop design
Parts:
- removed R18: 330k, Resistor_SMD:R_0603_1608Metric
- removed R26: 10M, Resistor_SMD:R_0603_1608Metric
- added JP1: Jumper_2_Bridged, Jumper:SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm, F.Cu at (160.8, 40.6)
- added U7: BQ24040DSQR, LCSC:WSON-10_L2.0-W2.0-P0.40-BL-EP, F.Cu at (135.5, 123.2)
Connections:
- C29 pad 1: VBUS -> Net-(JP1-B)
- C76 pad 1: /Inputs/VOL_{UP} -> /Inputs/VOL_{DOWN}
- C79 pad 1: /Inputs/VOL_{DOWN} -> /Inputs/VOL_{UP}
- Q3 pad 1: Net-(Q1-G) -> Net-(Q3-G)
- Q4 pad 3: Net-(Q1-G) -> Net-(Q3-G)
- Q5 pad 3: Net-(Q1-G) -> Net-(Q3-G)
- R34 pad 1: /Inputs/VOL_{UP} -> /Inputs/VOL_{DOWN}
- R39 pad 1: /Inputs/VOL_{DOWN} -> /Inputs/VOL_{UP}
- U3 pad 16: /RP2040/TFT_{LED} -> /RP2040/AUX4
- U3 pad 17: /Audio/AMP_{EN} -> /RP2040/AUX5
- U3 pad 18: /Inputs/VOL_{UP} -> /RP2040/AUX6
- U3 pad 27: /Inputs/VOL_{DOWN} -> /RP2040/AUX7
- U3 pad 28: /Power/OFF -> /RP2040/TFT_{LED}
- U3 pad 29: /Inputs/JOY_{SW} -> /Audio/AMP_{EN}
- U3 pad 30: /Power/ON -> /Power/OFF
- U3 pad 31: /Inputs/BTN_{SELECT} -> /Power/ON
- U3 pad 51: /RP2040/AUX7 -> /Inputs/VOL_{DOWN}
- U3 pad 52: Net-(U3-QSPI_SCLK) -> /Inputs/VOL_{SW}
- U3 pad 53: /RP2040/AUX4 -> /Inputs/JOY_{SW}
- U3 pad 54: /RP2040/AUX6 -> /Inputs/VOL_{UP}
- U3 pad 55: /RP2040/AUX5 -> /Inputs/BTN_{SELECT}
Routing:
- net VBUS: track 246.3 -> 144.2 mm, vias 10 -> 6
- net Net-(JP1-B): track 0.00 -> 102.1 mm, vias 0 -> 4

Commit message: Use display without PCB
Parts:
- removed U1: Display, Krecek:TftDisplay
- added REF**: Panel, Krecek:Panel, B.Cu at (126.0, 71.1)
- JOY1, SW4: moved to B.Cu
- moved SW4 20.4 mm to (181.0, 71.0), turned to 180 degrees
Routing:
- net /Inputs/BTN_{Y}: track 0.00 -> 92.4 mm, vias 0 -> 2
- net /RP2040/TFT_{LED}: track 75.1 -> 0.00 mm, vias 3 -> 0
- net /RP2040/AUX4: track 52.0 -> 127.1 mm, vias 0 -> 3
- net /Inputs/BTN_{B}: track 181.9 -> 108.5 mm, vias 4 -> 2
- net /Inputs/BTN_{X}: track 92.4 -> 73.4 mm
Other:
- board size 177.8 x 88.9 mm -> 152.4 x 63.5 mm

Commit message: hw: work on new board revision
Parts:
- removed the C54 at (182.1, 102.1)
- removed the C55 at (183.1, 102.1)
- removed JOY1: RKJXV1224005, LCSC:SW-TH_RKJXV1224005
- removed the Q4 at (154.0, 87.8)
- removed the Q5 at (158.4, 92.6)
- removed the R13 at (156.0, 118.3)
- removed the R35 at (80.6, 86.2)
- removed REF**: Panel, Krecek:Panel
- removed TP3, TP4: TestPoint, TestPoint:TestPoint_Pad_D1.0mm
- added C34: 100n, Capacitor_SMD:C_0402_1005Metric, F.Cu at (226.2, 22.7)
- added C78: 10u, Capacitor_SMD:C_0402_1005Metric, F.Cu at (134.4, 57.9)
- added C79: 10u, Capacitor_SMD:C_0402_1005Metric, F.Cu at (130.2, 64.3)
- added C80: 10u, Capacitor_SMD:C_0402_1005Metric, F.Cu at (135.4, 57.9)
- added D4: BAT54C, Package_TO_SOT_SMD:SOT-23, F.Cu at (227.2, 14.9)
- added D5: BAT54C, Package_TO_SOT_SMD:SOT-23, F.Cu at (227.2, 19.5)
- added FPC1: FPC-05F-18PH20, LCSC:FPC-SMD_18P-P0.50_FPC-05F-18PH20, F.Cu at (124.5, 70.1)
- added R10: 39k, Resistor_SMD:R_0603_1608Metric, F.Cu at (231.6, 13.7)
- added R18: 100k, Resistor_SMD:R_0402_1005Metric, F.Cu at (231.1, 23.0)
- added R19: 150k, Resistor_SMD:R_0603_1608Metric, F.Cu at (231.6, 16.2)
- added R3: 1k, Resistor_SMD:R_0402_1005Metric, F.Cu at (103.8, 63.1)
- added R40: 1M, Resistor_SMD:R_0402_1005Metric, F.Cu at (113.0, 45.0)
- added U11: PAM8302AASCR, LCSC:MSOP-8_L3.0-W3.0-P0.65-LS5.0-BL, F.Cu at (150.2, 91.9)
- added U13: FlatJoyCon, Krecek:FlatJoyCon, B.Cu at (185.4, 64.9)
- C77: value 100n -> 10u
- D3: footprint Diode_SMD:D_SMA -> LED_SMD:LED_0603_1608Metric
- R36: footprint LCSC:RES-ADJ-SMD_RDC506002A -> Krecek:bracket_Left
- R38: footprint LCSC:RES-ADJ-SMD_RDC506002A -> Krecek:bracket_Right
- SW2, SW3: moved to B.Cu
- U14: value PAM8302AASCR -> TSC2046EIRGVR; footprint LCSC:MSOP-8_L3.0-W3.0-P0.65-LS5.0-BL -> LCSC:VQFN-16_L4.0-W4.0-P0.65-TL-EP2.2
- moved C77 168.6 mm to (226.2, 3.56), turned to 0 degrees
- moved C71 157.2 mm to (59.3, 63.0)
- moved JP2 140.0 mm to (232.0, 64.1)
- moved C68 133.1 mm to (77.2, 83.1)
- moved R15 133.1 mm to (246.8, 45.6)
- moved R17 133.1 mm to (248.8, 45.6)
- moved R16 133.1 mm to (247.8, 45.6)
- moved R11 125.2 mm to (231.1, 21.1), turned to 0 degrees
- moved C69 123.9 mm to (68.0, 53.6)
- moved C40 108.2 mm to (227.7, 44.7)
- moved R26 108.2 mm to (229.2, 44.7)
- moved R22 108.2 mm to (235.3, 44.7)
- moved R23 108.2 mm to (233.8, 44.7)
- moved R24 108.2 mm to (232.3, 44.7)
- moved R25 108.2 mm to (230.8, 44.7)
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Connections:
- net /RP2040/RF_{CLK} renamed /RP2040/RF_{XOSC}
- C48 pad 2: Net-(U14-IN+) -> /Audio/HP_{LEFT}
- C49 pad 2: Net-(U14-IN-) -> /Audio/HP_{RIGHT}
- C77 pad 1: /Inputs/JOY_{SW} -> +3.3V
- Q3 pad 2: GND -> Net-(Q1-G)
- Q3 pad 3: Net-(Q3-D) -> GND
- Q6 pad 1: /Power/OFF -> /Display/TFT_{LED}
- Q6 pad 2: GND -> Net-(Q6-S)
- Q6 pad 3: Net-(Q3-D) -> GND
- R11 pad 1: +BATT -> GND
- R11 pad 2: Net-(R11-Pad2) -> /Power/ISET2
- R28 pad 1: Net-(Q3-D) -> GND
- R28 pad 2: /Power/V_{USB/BATT} -> Net-(Q3-G)
- SPK1 pad 2: Net-(U14-VO-) -> Net-(U11-VO-)
- SW2 pad 1: Net-(R11-Pad2) -> GND
- SW2 pad C: /Power/ON -> Net-(D4-Pad3)
- U1 pad 11: /MicroSD Card/SD_{MISO} -> /Display/TFT_{MISO}
- U1 pad 12: /MicroSD Card/SD_{CS} -> /Display/TFT_{CS}
- U1 pad 13: /MicroSD Card/SD_{SCLK} -> /Display/TFT_{SCLK}
- U1 pad 14: /MicroSD Card/SD_{MOSI} -> /Display/TFT_{MOSI}
- U1 pad 2: /RP2040/TFT_{MISO} -> /MicroSD Card/SD_{MISO}
- U1 pad 3: /RP2040/TFT_{CS} -> /MicroSD Card/SD_{CS}
- U1 pad 4: /RP2040/TFT_{SCK} -> /MicroSD Card/SD_{SCLK}
- U1 pad 5: /RP2040/TFT_{MOSI} -> /MicroSD Card/SD_{MOSI}
- U1 pad 6: /RP2040/TFT_{RS} -> /Power/ISET2
- U1 pad 7: /RP2040/RF_{CS} -> /Display/TFT_{LED}
- U1 pad 8: /RP2040/TFT_{RST} -> /Display/TFT_{RST}
- U1 pad 9: /Power/ISET2 -> /Display/TFT_{DC}
- U10 pad 13: Net-(U11-MONOOUT) -> unconnected-(U10-MONOOUT-Pad13)
- U12 pad 1: /RP2040/TFT_{SCK} -> /Display/TOUCH_{SCLK}
- U12 pad 2: /RP2040/TFT_{MISO} -> /Display/TOUCH_{MISO}
- U12 pad 20: /RP2040/TFT_{MOSI} -> /Display/TOUCH_{MOSI}
- U14 pad 1: /Audio/AMP_{EN} -> unconnected-(U14-BUSY-Pad1)
- U14 pad 2: Net-(U14-IN-) -> /Display/TOUCH_{MOSI}
- U14 pad 3: Net-(U14-IN+) -> /Display/TOUCH_{CS}
- U14 pad 4: (no net) -> /Display/TOUCH_{SCLK}
- U14 pad 5: Net-(SPK1-+) -> +3.3V
- U14 pad 6: +3.3V -> Net-(U14-X+)
- U14 pad 7: GND -> Net-(U14-Y+)
- U14 pad 8: Net-(U14-VO-) -> Net-(U14-X-)
- U2 pad 11: /RP2040/BUS3 -> /RP2040/BUS1
- U2 pad 12: /RP2040/AUX0 -> /RP2040/BUS0
- U2 pad 13: /RP2040/AUX1 -> /RP2040/AUX0
- U2 pad 14: /RP2040/AUX2 -> /RP2040/AUX1
- U2 pad 15: /RP2040/AUX3 -> /RP2040/AUX2
- U2 pad 16: /RP2040/AUX4 -> /RP2040/AUX3
- U2 pad 17: /RP2040/AUX5 -> /RP2040/AUX4
- U2 pad 18: /RP2040/AUX6 -> /RP2040/AUX5
- U2 pad 2: /RP2040/T_{MISO} -> /Display/TOUCH_{MISO}
- U2 pad 27: /RP2040/AUX7 -> /RP2040/AUX6
- U2 pad 28: /RP2040/TFT_{LED} -> /RP2040/AUX7
- U2 pad 3: /RP2040/T_{CS} -> /Display/TOUCH_{CS}
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Routing:
- net +3.3V: track 426.8 -> 72.8 mm, vias 21 -> 0
- net +5V: track 171.9 -> 19.7 mm, vias 7 -> 0
- net VBUS: track 144.2 -> 0.00 mm, vias 6 -> 0
- net /RP2040/AUX0: track 147.6 -> 5.46 mm
- net /RP2040/AUX1: track 146.5 -> 5.00 mm
- net /Audio/HP_{SENSE}: track 148.9 -> 8.21 mm, vias 5 -> 0
- net /RP2040/AUX2: track 142.2 -> 2.56 mm
- net +3.3VA: track 142.4 -> 2.85 mm, vias 4 -> 0
- net /RP2040/AUX3: track 141.4 -> 2.67 mm
- net /RP2040/AUX4: track 127.1 -> 2.39 mm, vias 3 -> 1
- net +BATT: track 117.1 -> 0.00 mm, vias 4 -> 0
- net /Inputs/BTN_{B}: track 108.5 -> 5.01 mm, vias 2 -> 1
- net /Audio/CDATA: track 105.6 -> 3.42 mm, vias 2 -> 1
- net Net-(JP1-B): track 102.1 -> 0.00 mm, vias 4 -> 0
- net /Inputs/VOL_{UP}: track 104.8 -> 4.03 mm, vias 0 -> 1
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- added copper zone on F.Cu, net Net-(Q6-S)
- removed copper zone on F.Cu, net +3.3VA
- removed copper zone on F.Cu, net +3.3VSD
- removed copper zone on F.Cu, net +5V
- removed copper zone on F.Cu, net /Power/vin
- removed copper zone on F.Cu, net /Power/vina
- removed copper zone on F.Cu, net VBUS
Other:
- outline, holes or cut-outs redrawn
