File: hw/krecek-0.9/inputs.kicad_sch (KiCad schematic)
At the start: 19 parts, among them SW5 TM-2023

Commit message: Swap volume up/down
Connections:
- net VOL_{DOWN}: now also C76.1, R34.1; no longer C79.1, R39.1
- net VOL_{UP}: now also C79.1, R39.1; no longer C76.1, R34.1
Changed lines of the file:
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@@
     (effects (font (size 1.27 1.27)) (justify left))
   )
-  (hierarchical_label "VOL_{DOWN}" (shape output) (at 63.5 152.4 0) (fields_autoplaced)
+  (hierarchical_label "VOL_{DOWN}" (shape output) (at 63.5 76.2 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left))
   )
-  (hierarchical_label "VOL_{UP}" (shape output) (at 63.5 76.2 0) (fields_autoplaced)
+  (hierarchical_label "VOL_{UP}" (shape output) (at 63.5 152.4 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left))
   )

Commit message: Fix input PMOS orientation (again)
Parts:
- renumbered C71 to C68, C72 to C69, C73 to C70, C74 to C71, C75 to C72, C76 to C73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

Commit message: Replace Joystick with flat JoyCon
Parts:
- removed C74: 100n, Capacitor_SMD:C_0402_1005Metric, symbol Device:C_Small
- removed JOY1: RKJXV1224005, LCSC:SW-TH_RKJXV1224005, symbol LCSC:RKJXV1224005
- removed R38: 3.3k, Resistor_SMD:R_0402_1005Metric, symbol Device:R_Small
- added U1: FlatJoyCon, Krecek:FlatJoyCon, symbol Krecek:FlatJoyCon
Connections:
- net +3.3V: now also U1.1 (Vcc), U1.4 (Vcc)
- net GND: now also U1.3 (GND), U1.6 (GND)
- net JOY_{X}: now also U1.5 (X)
- net JOY_{Y}: now also U1.2 (Y)

Commit message: Fix ERC-indicated issues
Parts:
- renumbered C68 to C67, C69 to C68, C70 to C69, C71 to C70, C72 to C71, C73 to C72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
Connections:
- net +3.3V: no longer U13.4 (Vcc)
- net GND: now also U13.2 (GND); no longer U13.3 (GND), U13.6 (GND)
- net JOY_{X}: now also U13.4 (X); no longer U13.5 (X)
- net JOY_{Y}: now also U13.3 (Y); no longer U13.2 (Y)

Commit message: hw: work on new board revision
Parts:
- R36: footprint LCSC:RES-ADJ-SMD_RDC506002A -> Krecek:bracket_Left
- R38: footprint LCSC:RES-ADJ-SMD_RDC506002A -> Krecek:bracket_Right
Changed lines of the file:
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@@
 			)
 		)
-		(property "Footprint" "LCSC:RES-ADJ-SMD_RDC506002A"
+		(property "Footprint" "Krecek:bracket_Left"
 			(at 120.65 100.33 0)
 			(effects
@@
 			)
 		)
-		(property "Footprint" "LCSC:RES-ADJ-SMD_RDC506002A"
+		(property "Footprint" "Krecek:bracket_Right"
 			(at 120.65 125.73 0)
 			(effects
