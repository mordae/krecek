File: hw/krecek-0.9/rp2040.kicad_sch (KiCad schematic)
At the start: 38 parts, among them J1 DAP, J2 AUX, SW1 SW_Push, U2 RP2040, U3 RP2040, U4 W25Q128JVS, Y1 12MHz

Commit message: Add display components to library
Also move CC1101 communication to second chip.
Resolves #13.
Connections:
- net AUX0: now also U3.13 (GPIO10); no longer U3.12 (GPIO9)
- net AUX1: now also U3.14 (GPIO11); no longer U3.13 (GPIO10)
- net AUX2: now also U3.15 (GPIO12); no longer U3.14 (GPIO11)
- net AUX3: now also U3.16 (GPIO13); no longer U3.15 (GPIO12)
- net AUX4: now also U3.17 (GPIO14); no longer U3.16 (GPIO13)
- net AUX5: now also U3.18 (GPIO15); no longer U3.17 (GPIO14)
- net AUX6: now also U3.27 (GPIO16); no longer U3.18 (GPIO15)
- net AUX7: now also U3.28 (GPIO17); no longer U3.27 (GPIO16)
- net BUS0: now also U3.8 (GPIO6); no longer U3.7 (GPIO5)
- net BUS1: now also U3.9 (GPIO7); no longer U3.8 (GPIO6)
- net BUS2: now also U3.11 (GPIO8); no longer U3.9 (GPIO7)
- net BUS3: now also U3.12 (GPIO9); no longer U3.11 (GPIO8)
- net RF_{CS}: now also U3.7 (GPIO5); no longer U2.7 (GPIO5)
- net TFT_{LED}: now also U2.7 (GPIO5); no longer U3.28 (GPIO17)
- net RF_{CLK} renamed RF_{XOSC}

Commit message: hw: use non-PCB screen with touch ADC
Connections:
- net T_{IRQ}: no longer names the net of U3.6 (GPIO4)
- no-connect marks 5 -> 6
Changed lines of the file:
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@@
   (no_connect (at 177.8 63.5))
   (no_connect (at 177.8 60.96))
+  (no_connect (at 228.6 63.5))
   (wire (pts (xy 228.6 86.36) (xy 254 86.36))
     (stroke (width 0) (type default))
@@
     (effects (font (size 1.27 1.27)) (justify right))
   )
-  (hierarchical_label "T_{IRQ}" (shape input) (at 228.6 63.5 0) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify left))
-  )
   (symbol (lib_id "Device:Crystal_GND24") (at 38.1 177.8 0) (unit 1)

Commit message: Replace Joystick with flat JoyCon
Connections:
- net JOY_{SW}: no longer names the net of U3.53 (QSPI_SD0)
- no-connect marks 6 -> 7
Changed lines of the file:
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@@
+	)
+	(no_connect
+		(at 177.8 76.2)
 	)
 	(no_connect
@@
 		)
 	)
-	(hierarchical_label "JOY_{SW}"
-		(shape input)
-		(at 177.8 76.2 180)
-		(fields_autoplaced yes)
-		(effects
-			(font
-				(size 1.27 1.27)
-			)
-			(justify right)
-		)
-	)

Commit message: Fix ERC-indicated issues
Parts:
- renumbered U2 to U1, U3 to U2, U4 to U3

Commit message: hw: work on new board revision
Parts:
- added R40: 1M, Resistor_SMD:R_0402_1005Metric, symbol Device:R_Small
Connections:
- net AUX0: now also R40.2
- net AUX1: now also R40.1
- net BUS0: now also U2.12 (GPIO9); no longer U2.8 (GPIO6)
- net BUS1: now also U2.11 (GPIO8); no longer U2.9 (GPIO7)
- net BUS2: now also U2.9 (GPIO7); no longer U2.11 (GPIO8)
- net BUS3: now also U2.8 (GPIO6); no longer U2.12 (GPIO9)
- net CHG_{ISET2}: now also U1.6 (GPIO4); no longer U1.9 (GPIO7)
- net SD_{CS}: now also U1.3 (GPIO1); no longer U1.12 (GPIO9)
- net SD_{MISO}: now also U1.2 (GPIO0); no longer U1.11 (GPIO8)
- net SD_{MOSI}: now also U1.5 (GPIO3); no longer U1.14 (GPIO11)
- net SD_{SCLK}: now also U1.4 (GPIO2); no longer U1.13 (GPIO10)
- net TFT_{CS}: now also U1.12 (GPIO9); no longer U1.3 (GPIO1)
- net TFT_{MISO}: now also U1.11 (GPIO8); no longer U1.2 (GPIO0)
- net TFT_{MOSI}: now also U1.14 (GPIO11); no longer U1.5 (GPIO3)
- net TFT_{RS}: now also U1.9 (GPIO7); no longer U1.6 (GPIO4)
- net TFT_{SCK}: now also U1.13 (GPIO10); no longer U1.4 (GPIO2)
Other:
- note added: "FM receiver :-)"
Changed lines of the file:
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@@
 	(wire
 		(pts
+			(xy 269.24 114.3) (xy 279.4 114.3)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 198.12 45.72) (xy 198.12 44.45)
 		)
@@
 	(wire
 		(pts
-			(xy 228.6 73.66) (xy 254 73.66)
+			(xy 228.6 71.12) (xy 254 71.12)
 		)
 		(stroke
@@
 	(wire
 		(pts
+			(xy 254 114.3) (xy 264.16 114.3)
+		)
+		(stroke
+			(width 0)
+			(type default)
+		)
+	)
+	(wire
+		(pts
 			(xy 53.34 38.1) (xy 62.23 38.1)
 		)
@@
 	(wire
 		(pts
-			(xy 228.6 76.2) (xy 254 76.2)
+			(xy 228.6 68.58) (xy 254 68.58)
 		)
 		(stroke
@@
 	(wire
 		(pts
-			(xy 228.6 68.58) (xy 254 68.58)
+			(xy 228.6 76.2) (xy 254 76.2)
 		)
 		(stroke
@@
 	(wire
 		(pts
-			(xy 228.6 71.12) (xy 254 71.12)
+			(xy 228.6 73.66) (xy 254 73.66)
 		)
 		(stroke
@@
 		)
 	)
+	(text "FM receiver :-)"
+		(exclude_from_sim no)
+		(at 266.446 118.11 0)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+		)
+	)
+	(label "AUX0"
+		(at 279.4 114.3 180)
+		(fields_autoplaced yes)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify right bottom)
+		)
+	)
 	(label "QSPI_SS"
 		(at 38.1 71.12 0)
@@
 	)
 	(label "BUS0"
-		(at 254 68.58 180)
+		(at 254 76.2 180)
 		(fields_autoplaced yes)
 		(effects
@@
 	)
 	(label "BUS1"
-		(at 254 71.12 180)
+		(at 254 73.66 180)
 		(fields_autoplaced yes)
 		(effects
@@
 	)
 	(label "BUS3"
-		(at 254 76.2 180)
+		(at 254 68.58 180)
 		(fields_autoplaced yes)
 		(effects
@@
 	)
 	(label "BUS2"
-		(at 254 73.66 180)
+		(at 254 71.12 180)
 		(fields_autoplaced yes)
 		(effects
@@
 		)
 	)
+	(label "AUX1"
+		(at 254 114.3 0)
+		(fields_autoplaced yes)
+		(effects
+			(font
+				(size 1.27 1.27)
+			)
+			(justify left bottom)
+		)
+	)
 	(label "QSPI_SD2"
 		(at 139.7 175.26 180)
@@
 	(hierarchical_label "SD_{MISO}"
 		(shape input)
-		(at 101.6 73.66 0)
+		(at 101.6 53.34 0)
 		(fields_autoplaced yes)
 		(effects
@@
 	(hierarchical_label "CHG_{ISET2}"
 		(shape output)
-		(at 101.6 71.12 0)
+		(at 101.6 63.5 0)
 		(fields_autoplaced yes)
 		(effects
@@
 	(hierarchical_label "TFT_{CS}"
 		(shape output)
-		(at 101.6 55.88 0)
+		(at 101.6 76.2 0)
 		(fields_autoplaced yes)
 		(effects
@@
 	(hierarchical_label "SD_{CS}"
 		(shape output)
-		(at 101.6 76.2 0)
+		(at 101.6 55.88 0)
 		(fields_autoplaced yes)
 		(effects
@@
 	(hierarchical_label "TFT_{MISO}"
 		(shape input)
-		(at 101.6 53.34 0)
+		(at 101.6 73.66 0)
 		(fields_autoplaced yes)
 		(effects
@@
 	(hierarchical_label "TFT_{MOSI}"
 		(shape output)
-		(at 101.6 60.96 0)
+		(at 101.6 81.28 0)
 		(fields_autoplaced yes)
 		(effects
@@
 	(hierarchical_label "SD_{MOSI}"
 		(shape output)
-		(at 101.6 81.28 0)
+		(at 101.6 60.96 0)
 		(fields_autoplaced yes)
 		(effects
@@
 	(hierarchical_label "TFT_{SCK}"
 		(shape output)
-		(at 101.6 58.42 0)
+		(at 101.6 78.74 0)
 		(fields_autoplaced yes)
 		(effects
@@
 	(hierarchical_label "SD_{SCLK}"
 		(shape output)
-		(at 101.6 78.74 0)
+		(at 101.6 58.42 0)
 		(fields_autoplaced yes)
 		(effects
@@
 	(hierarchical_label "TFT_{RS}"
 		(shape output)
-		(at 101.6 63.5 0)
+		(at 101.6 71.12 0)
 		(fields_autoplaced yes)
 		(effects
@@
 					(unit 1)
 				)
+			)
+		)
+	)
+	(symbol
+		(lib_id "Device:R_Small")
+		(at 266.7 114.3 90)
+		(mirror x)
+		(unit 1)
+		(exclude_from_sim no)
+		(in_bom yes)
+		(on_board yes)
+		(dnp no)
+		(fields_autoplaced yes)
+		(property "Reference" "R40"
+			(at 266.7 109.22 90)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+			)
+		)
+		(property "Value" "1M"
+			(at 266.7 111.76 90)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+			)
+		)
+		(property "Footprint" "Resistor_SMD:R_0402_1005Metric"
+			(at 266.7 114.3 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Datasheet" "~"
+			(at 266.7 114.3 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "Description" "Resistor, small symbol"
+			(at 266.7 114.3 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(property "LCSC Part" "C26083"
+			(at 266.7 114.3 0)
+			(effects
+				(font
+					(size 1.27 1.27)
+				)
+				(hide yes)
+			)
+		)
+		(pin "1"
+		)
+		(pin "2"
+		)
+		(instances
+			(project "krecek-0.9"
+				(path "/8888f37b-ecc2-47df-8824-4b4e1e726451/6537dbea-4e11-4137-b8a0-9ae6b128c4e4"
+					(reference "R40")
+					(unit 1)
+				)
