File: hw/krecek-0.9/audio.kicad_sch (KiCad schematic)
At the start: 32 parts, among them CN1 PJ-313B6-B, Q1 PT334, Q2 AO3400A, U11 ES8312, U12 PAM8302AASCR

Commit message: hw: fix headphone driver design
Parts:
- removed C7 (x2): 1u, Capacitor_SMD:C_0402_1005Metric, symbol Device:C_Small
Connections:
- net HP_{LEFT}: now also C7.2, TP1.1, U12.3 (IN+)
- net HP_{RIGHT}: now also C7.2, TP2.1, U12.2 (IN-)
- net at U12.8 (VO-): now also SPK1.2
- no-connect marks 3 -> 4
Other:
- moved on the sheet: TP1, TP2
Changed lines of the file:
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@@
   (junction (at 71.12 96.52) (diameter 0) (color 0 0 0 0)
   )
-  (junction (at 139.7 142.24) (diameter 0) (color 0 0 0 0)
-  )
   (junction (at 71.12 172.72) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 139.7 134.62) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 139.7 132.08) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 146.05 38.1) (diameter 0) (color 0 0 0 0)
   )
@@
   (junction (at 165.1 38.1) (diameter 0) (color 0 0 0 0)
   )
-  (junction (at 172.72 132.08) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 172.72 134.62) (diameter 0) (color 0 0 0 0)
-  )
+  (no_connect (at 91.44 142.24))
   (no_connect (at 48.26 139.7))
   (no_connect (at 91.44 119.38))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 149.86 142.24) (xy 165.1 142.24))
+  (wire (pts (xy 139.7 127) (xy 152.4 127))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 149.86 144.78) (xy 165.1 144.78))
+  (wire (pts (xy 139.7 134.62) (xy 139.7 139.7))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 139.7 139.7) (xy 152.4 139.7))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 129.54 134.62) (xy 172.72 134.62))
+  (wire (pts (xy 129.54 134.62) (xy 139.7 134.62))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 91.44 142.24) (xy 139.7 142.24))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 68.58 172.72) (xy 71.12 172.72))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 139.7 127) (xy 139.7 132.08))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 25.4 147.32) (xy 29.21 147.32))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 139.7 144.78) (xy 144.78 144.78))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 63.5 34.29) (xy 63.5 39.37))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 139.7 142.24) (xy 139.7 144.78))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 165.1 100.33) (xy 165.1 101.6))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 139.7 142.24) (xy 144.78 142.24))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 177.8 33.02) (xy 190.5 33.02))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 172.72 134.62) (xy 205.74 134.62))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 172.72 132.08) (xy 205.74 132.08))
+  (wire (pts (xy 139.7 132.08) (xy 205.74 132.08))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 139.7 134.62) (xy 205.74 134.62))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 146.05 38.1) (xy 146.05 41.91))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 129.54 132.08) (xy 172.72 132.08))
+  (wire (pts (xy 129.54 132.08) (xy 139.7 132.08))
     (stroke (width 0) (type default))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "HP_{LEFT}" (at 165.1 142.24 180) (fields_autoplaced)
+  (label "HP_{LEFT}" (at 152.4 127 180) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right bottom))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "HP_{RIGHT}" (at 165.1 144.78 180) (fields_autoplaced)
+  (label "HP_{RIGHT}" (at 152.4 139.7 180) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right bottom))
   )
@@
     )
   )
-  (symbol (lib_id "Connector:TestPoint") (at 172.72 132.08 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "TP1" (at 175.26 127.508 0)
+  (symbol (lib_id "Connector:TestPoint") (at 152.4 127 270) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "TP1" (at 157.48 125.73 90)
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "TestPoint" (at 175.26 130.048 0)
+    (property "Value" "TestPoint" (at 157.48 128.27 90)
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "TestPoint:TestPoint_Pad_D1.0mm" (at 177.8 132.08 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (at 177.8 132.08 0)
+    (property "Footprint" "TestPoint:TestPoint_Pad_D1.0mm" (at 152.4 132.08 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 152.4 132.08 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
   )
-  (symbol (lib_id "Device:C_Small") (at 147.32 144.78 90) (mirror x) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "C7" (at 147.3263 148.59 90)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Value" "1u" (at 147.3263 151.13 90)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "Capacitor_SMD:C_0402_1005Metric" (at 147.32 144.78 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (at 147.32 144.78 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "LCSC" "C52923" (at 147.32 144.78 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-    (pin "2")
-    (instances
-      (project "barbecue"
-        (path "/12829710-d93a-4fa1-96c6-084c1af2e761"
-          (reference "C7") (unit 1)
-        )
-      )
-      (project "bento-vna"
-        (path "/36176a8e-13d1-429b-8815-63472bc0665c"
-          (reference "C3") (unit 1)
-        )
-      )
-      (project "pipi"
-        (path "/5de6f2b6-19be-45cf-b069-ee289a326d21"
-          (reference "C3") (unit 1)
-        )
-        (path "/5de6f2b6-19be-45cf-b069-ee289a326d21/5b1ff778-5e2f-4eb6-acb1-23bd0a5149e9"
-          (reference "C3") (unit 1)
-        )
-        (path "/5de6f2b6-19be-45cf-b069-ee289a326d21/882742c5-0484-4b86-b485-99790a82e2a9"
-          (reference "C3") (unit 1)
-        )
-      )
-      (project "pipi"
-        (path "/73d1f64b-b6d8-45c3-ab75-e79bce2c5a38/350168a7-ca84-4da6-868a-c5a486a494d0"
-          (reference "C3") (unit 1)
-        )
-        (path "/73d1f64b-b6d8-45c3-ab75-e79bce2c5a38/94670045-b9e9-4921-8dd4-cc6059cd92ef"
-          (reference "C33") (unit 1)
-        )
-      )
-      (project "krecek-0.9"
-        (path "/8888f37b-ecc2-47df-8824-4b4e1e726451/a7733ec7-68c7-444f-aac5-8a965be5cbce"
-          (reference "C51") (unit 1)
-        )
-      )
-    )
-  )
-  (symbol (lib_id "Connector:TestPoint") (at 172.72 134.62 180) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "TP2" (at 175.26 136.652 0)
-      (effects (font (size 1.27 1.27)) (justify right))
-    )
-    (property "Value" "TestPoint" (at 175.26 139.192 0)
-      (effects (font (size 1.27 1.27)) (justify right))
-    )
-    (property "Footprint" "TestPoint:TestPoint_Pad_D1.0mm" (at 167.64 134.62 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (at 167.64 134.62 0)
+  (symbol (lib_id "Connector:TestPoint") (at 152.4 139.7 270) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "TP2" (at 157.48 138.43 90)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "TestPoint" (at 157.48 140.97 90)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "TestPoint:TestPoint_Pad_D1.0mm" (at 152.4 144.78 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 152.4 144.78 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
         )
       )
-    )
-  )
-  (symbol (lib_id "Device:C_Small") (at 147.32 142.24 90) (mirror x) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "C7" (at 147.3263 135.89 90)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Value" "1u" (at 147.3263 138.43 90)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "Capacitor_SMD:C_0402_1005Metric" (at 147.32 142.24 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (at 147.32 142.24 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "LCSC" "C52923" (at 147.32 142.24 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-    (pin "2")
-    (instances
-      (project "barbecue"
-        (path "/12829710-d93a-4fa1-96c6-084c1af2e761"
-          (reference "C7") (unit 1)
-        )
-      )
-      (project "bento-vna"
-        (path "/36176a8e-13d1-429b-8815-63472bc0665c"
-          (reference "C3") (unit 1)
-        )
-      )
-      (project "pipi"
-        (path "/5de6f2b6-19be-45cf-b069-ee289a326d21"
-          (reference "C3") (unit 1)
-        )
-        (path "/5de6f2b6-19be-45cf-b069-ee289a326d21/5b1ff778-5e2f-4eb6-acb1-23bd0a5149e9"
-          (reference "C3") (unit 1)
-        )
-        (path "/5de6f2b6-19be-45cf-b069-ee289a326d21/882742c5-0484-4b86-b485-99790a82e2a9"
-          (reference "C3") (unit 1)
-        )
-      )
-      (project "pipi"
-        (path "/73d1f64b-b6d8-45c3-ab75-e79bce2c5a38/350168a7-ca84-4da6-868a-c5a486a494d0"
-          (reference "C3") (unit 1)
-        )
-        (path "/73d1f64b-b6d8-45c3-ab75-e79bce2c5a38/94670045-b9e9-4921-8dd4-cc6059cd92ef"
-          (reference "C33") (unit 1)
-        )
-      )
-      (project "krecek-0.9"
-        (path "/8888f37b-ecc2-47df-8824-4b4e1e726451/a7733ec7-68c7-444f-aac5-8a965be5cbce"
-          (reference "C50") (unit 1)
-        )
-      )

Commit message: Use display without PCB
Connections:
- net at U12.8 (VO-): now also SPK1.2

Commit message: Fix ERC-indicated issues
Parts:
- removed U12: PAM8302AASCR, LCSC:MSOP-8_L3.0-W3.0-P0.65-LS5.0-BL, symbol LCSC:PAM8302AASCR
- added U11: PAM8302AASCR, LCSC:MSOP-8_L3.0-W3.0-P0.65-LS5.0-BL, symbol LCSC:PAM8302AASCR
- renumbered R31 to R29, U11 to U10
Connections:
- net +3.3V: now also U11.6 (VDD)
- net AMP_{EN}: now also U11.1 (~{SD})
- net GND: now also U11.7 (GND)
- net HP_{LEFT}: now also U11.3 (IN+)
- net HP_{RIGHT}: now also U11.2 (IN-)
- net at SPK1.1 (+): now also U11.5 (VO+)
- net at SPK1.2: now also U11.8 (VO-)
