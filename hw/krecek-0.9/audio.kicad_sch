File: hw/krecek-0.9/audio.kicad_sch (KiCad schematic)
At the start: 30 parts, among them CN1 PJ-313B6-B, Q1 PT334, Q2 AO3400A, U11 ES8312, U12 TPA2028D1YZFT

Commit message: Hardware as sent for manufacturing
Parts:
- added TP3, TP4: TestPoint, TestPoint:TestPoint_Pad_D1.0mm, symbol Connector:TestPoint
Connections:
- net at C7.2, U12.B3 (IN+): now also TP3.1
- net at C7.2, U12.C3 (IN-): now also TP4.1
Other:
- moved on the sheet: C7
Changed lines of the file:
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@@
   (junction (at 165.1 38.1) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 172.72 132.08) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 172.72 134.62) (diameter 0) (color 0 0 0 0)
   )
   (no_connect (at 48.26 139.7))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 180.34 134.62) (xy 195.58 134.62))
+  (wire (pts (xy 129.54 134.62) (xy 172.72 134.62))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 172.72 134.62) (xy 195.58 134.62))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 172.72 132.08) (xy 195.58 132.08))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 165.1 76.2) (xy 165.1 80.01))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 91.44 134.62) (xy 175.26 134.62))
+  (wire (pts (xy 91.44 134.62) (xy 124.46 134.62))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 180.34 132.08) (xy 195.58 132.08))
+  (wire (pts (xy 129.54 132.08) (xy 172.72 132.08))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 91.44 132.08) (xy 175.26 132.08))
+  (wire (pts (xy 91.44 132.08) (xy 124.46 132.08))
     (stroke (width 0) (type default))
   )
@@
         (path "/8888f37b-ecc2-47df-8824-4b4e1e726451/a7733ec7-68c7-444f-aac5-8a965be5cbce"
           (reference "#PWR077") (unit 1)
+        )
+      )
+    )
+  )
+  (symbol (lib_id "Connector:TestPoint") (at 172.72 132.08 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "TP3" (at 175.26 127.508 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "TestPoint" (at 175.26 130.048 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "TestPoint:TestPoint_Pad_D1.0mm" (at 177.8 132.08 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 177.8 132.08 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "krecek-0.9"
+        (path "/8888f37b-ecc2-47df-8824-4b4e1e726451/a7733ec7-68c7-444f-aac5-8a965be5cbce"
+          (reference "TP3") (unit 1)
         )
       )
@@
     )
   )
+  (symbol (lib_id "Connector:TestPoint") (at 172.72 134.62 180) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "TP4" (at 175.26 136.652 0)
+      (effects (font (size 1.27 1.27)) (justify right))
+    )
+    (property "Value" "TestPoint" (at 175.26 139.192 0)
+      (effects (font (size 1.27 1.27)) (justify right))
+    )
+    (property "Footprint" "TestPoint:TestPoint_Pad_D1.0mm" (at 167.64 134.62 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 167.64 134.62 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "krecek-0.9"
+        (path "/8888f37b-ecc2-47df-8824-4b4e1e726451/a7733ec7-68c7-444f-aac5-8a965be5cbce"
+          (reference "TP4") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "power:GND") (at 127 165.1 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
@@
     )
   )
-  (symbol (lib_id "Device:C_Small") (at 177.8 132.08 90) (mirror x) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "C7" (at 177.8063 125.73 90)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Value" "1u" (at 177.8063 128.27 90)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "Capacitor_SMD:C_0402_1005Metric" (at 177.8 132.08 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (at 177.8 132.08 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "LCSC" "C52923" (at 177.8 132.08 0)
+  (symbol (lib_id "Device:C_Small") (at 127 132.08 90) (mirror x) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "C7" (at 127.0063 125.73 90)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Value" "1u" (at 127.0063 128.27 90)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "Capacitor_SMD:C_0402_1005Metric" (at 127 132.08 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 127 132.08 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LCSC" "C52923" (at 127 132.08 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
   )
-  (symbol (lib_id "Device:C_Small") (at 177.8 134.62 90) (mirror x) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "C7" (at 177.8063 138.43 90)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Value" "1u" (at 177.8063 140.97 90)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "Capacitor_SMD:C_0402_1005Metric" (at 177.8 134.62 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (at 177.8 134.62 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "LCSC" "C52923" (at 177.8 134.62 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+  (symbol (lib_id "Device:C_Small") (at 127 134.62 90) (mirror x) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "C7" (at 127.0063 138.43 90)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Value" "1u" (at 127.0063 140.97 90)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "Capacitor_SMD:C_0402_1005Metric" (at 127 134.62 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 127 134.62 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LCSC" "C52923" (at 127 134.62 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: Commit forgotten changes
Parts:
- removed U12: TPA2028D1YZFT, LCSC:TPA2028, symbol LCSC:TPA2028D1YZFT
- added U14: PAM8302AASCR, LCSC:MSOP-8_L3.0-W3.0-P0.65-LS5.0-BL, symbol LCSC:PAM8302AASCR
Connections:
- net +3.3V: now also U14.6 (VDD)
- net AMP_{EN}: now also U14.1 (~{SD})
- net GND: now also U14.7 (GND)
- net at C7.2, TP3.1: now also U14.3 (IN+)
- net at C7.2, TP4.1: now also U14.2 (IN-)
- net at SPK1.1 (+): now also U14.5 (VO+)
- net at SPK1.2: now also U14.8 (VO-)
Other:
- moved on the sheet: SPK1
Changed lines of the file:
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@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 172.72 134.62) (xy 195.58 134.62))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 172.72 132.08) (xy 195.58 132.08))
+  (wire (pts (xy 172.72 134.62) (xy 205.74 134.62))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 172.72 132.08) (xy 205.74 132.08))
     (stroke (width 0) (type default))
   )
@@
     (effects (font (size 1.27 1.27)) (justify right bottom))
   )
-  (hierarchical_label "AMP_{EN}" (shape input) (at 195.58 144.78 180) (fields_autoplaced)
+  (hierarchical_label "AMP_{EN}" (shape input) (at 205.74 125.73 180) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right))
   )
@@
     (effects (font (size 1.27 1.27)) (justify right))
   )
-  (hierarchical_label "CCLK" (shape input) (at 195.58 139.7 180) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify right))
-  )
   (hierarchical_label "DAC" (shape input) (at 91.44 111.76 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left))
@@
   (hierarchical_label "ADC" (shape output) (at 91.44 114.3 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left))
-  )
-  (hierarchical_label "CDATA" (shape input) (at 195.58 142.24 180) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify right))
   )
   (hierarchical_label "CDATA" (shape bidirectional) (at 48.26 111.76 180) (fields_autoplaced)
@@
     )
   )
-  (symbol (lib_id "power:GND") (at 233.68 144.78 90) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR074" (at 240.03 144.78 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "GND" (at 237.49 144.78 90)
-      (effects (font (size 1.27 1.27)) (justify right))
-    )
-    (property "Footprint" "" (at 233.68 144.78 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (at 233.68 144.78 0)
+  (symbol (lib_id "power:GND") (at 215.9 143.51 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "#PWR074" (at 215.9 149.86 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (at 215.9 148.59 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "" (at 215.9 143.51 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 215.9 143.51 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
         (path "/8888f37b-ecc2-47df-8824-4b4e1e726451/a7733ec7-68c7-444f-aac5-8a965be5cbce"
           (reference "#PWR074") (unit 1)
+        )
+      )
+    )
+  )
+  (symbol (lib_id "LCSC:PAM8302AASCR") (at 215.9 132.08 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "U14" (at 217.5511 120.65 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "PAM8302AASCR" (at 217.5511 123.19 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "LCSC:MSOP-8_L3.0-W3.0-P0.65-LS5.0-BL" (at 215.9 151.13 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "https://lcsc.com/product-detail/Audio-OpAmps_DIODES_PAM8302AASCR_PAM8302AASCR_C113367.html" (at 215.9 153.67 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LCSC Part" "C113367" (at 215.9 156.21 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "7")
+    (pin "8")
+    (pin "3")
+    (pin "2")
+    (pin "6")
+    (pin "5")
+    (pin "1")
+    (pin "8")
+    (instances
+      (project "krecek-0.9"
+        (path "/8888f37b-ecc2-47df-8824-4b4e1e726451/a7733ec7-68c7-444f-aac5-8a965be5cbce"
+          (reference "U14") (unit 1)
         )
       )
@@
     )
   )
-  (symbol (lib_id "power:+3.3V") (at 233.68 132.08 270) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "#PWR072" (at 229.87 132.08 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "+3.3V" (at 237.49 132.08 90)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "" (at 233.68 132.08 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (at 233.68 132.08 0)
+  (symbol (lib_id "power:+3.3V") (at 215.9 123.19 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "#PWR072" (at 215.9 127 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+3.3V" (at 215.9 118.11 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "" (at 215.9 123.19 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 215.9 123.19 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
   )
-  (symbol (lib_id "LCSC:FS-1540") (at 237.49 138.43 0) (mirror x) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "SPK1" (at 242.57 137.16 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Value" "FS-1540" (at 242.57 139.7 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "LCSC:BUZ-SMD_5P-L15.0-W15.0-P13.7-BL" (at 237.49 125.73 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (at 237.49 138.43 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "LCSC Part" "C482341" (at 237.49 123.19 0)
+  (symbol (lib_id "LCSC:FS-1540") (at 229.87 134.62 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "SPK1" (at 234.95 133.35 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "FS-1540" (at 234.95 135.89 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "LCSC:BUZ-SMD_5P-L15.0-W15.0-P13.7-BL" (at 229.87 147.32 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 229.87 134.62 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "LCSC Part" "C482341" (at 229.87 149.86 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
         )
       )
-    )
-  )
-  (symbol (lib_id "LCSC:TPA2028D1YZFT") (at 214.63 139.7 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "U12" (at 214.63 124.46 0)
-      (effects (font (size 1.524 1.524)))
-    )
-    (property "Value" "TPA2028D1YZFT" (at 214.63 127 0)
-      (effects (font (size 1.524 1.524)))
-    )
-    (property "Footprint" "LCSC:TPA2028" (at 214.63 152.4 0)
-      (effects (font (size 1.27 1.27) italic) hide)
-    )
-    (property "Datasheet" "TPA2028D1YZFT" (at 214.63 154.94 0)
-      (effects (font (size 1.27 1.27) italic) hide)
-    )
-    (property "LCSC Part" "C2869063" (at 214.63 139.7 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "A1")
-    (pin "A2")
-    (pin "A3")
-    (pin "B1")
-    (pin "B2")
-    (pin "B3")
-    (pin "C1")
-    (pin "C2")
-    (pin "C3")
-    (instances
-      (project "krecek-0.9"
-        (path "/8888f37b-ecc2-47df-8824-4b4e1e726451/a7733ec7-68c7-444f-aac5-8a965be5cbce"
-          (reference "U12") (unit 1)
-        )
-      )

Commit message: Fix input PMOS orientation (again)
Parts:
- renumbered R28 to R31, TP3 to TP1, TP4 to TP2, U14 to U12
Connections:
- net at U12.8 (VO-): now also SPK1.2
