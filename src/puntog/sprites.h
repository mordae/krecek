#pragma once
#include "common.h"
#include <sdk.h>
#include <stdio.h>
#include <stdarg.h>

// 8x12 Zombie Walk Animation Frame 0 (2 bits per pixel, 24 bytes)
static const uint8_t sp_zombie_f0[24] = {
	0x15, 0x54, 0x6a, 0xa9, 0x7a, 0xb9, 0x65, 0x59,
	0x1a, 0xa4, 0x6a, 0xa9, 0x66, 0x99, 0x66, 0x99,
	0x1a, 0xa4, 0x18, 0x24, 0x18, 0x24, 0x54, 0x15
};

// 8x12 Zombie Walk Animation Frame 1 (2 bits per pixel, 24 bytes)
static const uint8_t sp_zombie_f1[24] = {
	0x15, 0x54, 0x6a, 0xa9, 0x7a, 0xb9, 0x65, 0x59,
	0x1a, 0xa4, 0x6a, 0xa9, 0x69, 0x69, 0x19, 0x64,
	0x1a, 0xa4, 0x19, 0x24, 0x06, 0x18, 0x15, 0x15
};

// 8x6 Coin Frame 0 (12 bytes)
static const uint8_t sp_coin_f0[12] = {
	0x15, 0x40, 0x6e, 0x90, 0x7e, 0x90, 0x6a, 0x90, 0x6a, 0x90, 0x15, 0x40
};

// 8x6 Coin Frame 1 (12 bytes)
static const uint8_t sp_coin_f1[12] = {
	0x05, 0x00, 0x1b, 0x40, 0x1f, 0x40, 0x1a, 0x40, 0x1a, 0x40, 0x05, 0x00
};

// 8x8 Magic Potion Pickup (16 bytes)
static const uint8_t sp_potion[16] = {
	0x01, 0x40, 0x01, 0x40, 0x06, 0x90, 0x1b, 0xa4,
	0x1b, 0xa4, 0x1a, 0xa4, 0x05, 0x50, 0x00, 0x00
};

// 8x8 Heart Pickup (16 bytes)
static const uint8_t sp_heart[16] = {
	0x14, 0x50, 0x6d, 0xa4, 0x7e, 0xa4, 0x6a, 0xa4,
	0x1a, 0x90, 0x06, 0x40, 0x01, 0x00, 0x00, 0x00
};

// 8x8 Spell Icons (16 bytes each)
static const uint8_t sp_spell_icons[NUM_SPELLS][16] = {
	// 0: Fireball
	{ 0x01, 0x00, 0x06, 0x40, 0x1b, 0x90, 0x1f, 0xd0,
	  0x6f, 0xe4, 0x6f, 0xa4, 0x1a, 0x90, 0x05, 0x40 },
	// 1: Ice Dagger
	{ 0x00, 0x40, 0x01, 0xd0, 0x06, 0xd0, 0x1b, 0x90,
	  0x1e, 0x40, 0x55, 0x00, 0x19, 0x00, 0x04, 0x00 },
	// 2: Magic Missile
	{ 0x01, 0x40, 0x07, 0xd0, 0x1f, 0xf4, 0x7e, 0xbd,
	  0x1f, 0xf4, 0x07, 0xd0, 0x11, 0x44, 0x40, 0x01 },
	// 3: Arcane Shield
	{ 0x55, 0x55, 0x6f, 0xf9, 0x6e, 0xb9, 0x6e, 0xb9,
	  0x1b, 0xe4, 0x1a, 0xa4, 0x06, 0x90, 0x01, 0x40 },
	// 4: Rune Trap
	{ 0x01, 0x40, 0x06, 0x90, 0x1b, 0xe4, 0x6d, 0x79,
	  0x6d, 0x79, 0x1b, 0xe4, 0x06, 0x90, 0x01, 0x40 },
};

// Fast 2-bit indexed sprite renderer with origin translation and screen clipping
static inline void draw_sprite_2bpp(int world_x, int world_y, const uint8_t *data,
				    int w, int h, Palette4 pal, bool flip_x)
{
	int bytes_per_row = (w + 3) / 4;

	for (int dy = 0; dy < h; dy++) {
		int py = world_y + dy;

		for (int dx = 0; dx < w; dx++) {
			int px = flip_x ? (world_x + (w - 1 - dx)) : (world_x + dx);

			int byte_idx = dy * bytes_per_row + (dx / 4);
			int bit_shift = 6 - (dx % 4) * 2;
			uint8_t color_idx = (data[byte_idx] >> bit_shift) & 0x03;

			if (color_idx > 0) {
				tft_draw_pixel(px, py, pal.c[color_idx]);
			}
		}
	}
}

// 3x5 Pixel Font Lookup Table (128 ASCII entries)
static const uint16_t font3x5[128] = {
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
	0x0000, 0x2482, 0x0000, 0x0000, 0x2f7a, 0x52a5, 0x0000, 0x0000,
	0x0000, 0x0000, 0x0000, 0x05d0, 0x0000, 0x01c0, 0x0002, 0x12a4,
	0x7b6f, 0x2492, 0x73e7, 0x73cf, 0x5bc9, 0x79cf, 0x79ef, 0x7252,
	0x7bef, 0x7bcf, 0x0410, 0x0000, 0x1511, 0x0E38, 0x4454, 0x0000,
	0x0000, 0x7bed, 0x6bae, 0x7927, 0x6b6e, 0x79a7, 0x79a4, 0x796f,
	0x5bed, 0x7497, 0x126f, 0x5bad, 0x4927, 0x5f6d, 0x7b6d, 0x7b6f,
	0x7be4, 0x7b79, 0x7bad, 0x79cf, 0x7492, 0x5b6f, 0x5b6a, 0x5b7d,
	0x5aad, 0x5a92, 0x72a7, 0x6926, 0x0000, 0x324B, 0x0000, 0x0007,
	0x0000, 0x7bed, 0x6bae, 0x7927, 0x6b6e, 0x79a7, 0x79a4, 0x796f,
	0x5bed, 0x7497, 0x126f, 0x5bad, 0x4927, 0x5f6d, 0x7b6d, 0x7b6f,
	0x7be4, 0x7b79, 0x7bad, 0x79cf, 0x7492, 0x5b6f, 0x5b6a, 0x5b7d,
	0x5aad, 0x5a92, 0x72a7, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000,
};

static inline void hud_draw_text(int sx, int sy, color_t color, const char *str)
{
	while (*str) {
		unsigned char c = (unsigned char)*str++;
		if (c >= 128) c = ' ';
		uint16_t glyph = font3x5[c];
		for (int row = 0; row < 5; row++) {
			int py = sy + row;
			if (py < 0 || py >= TFT_HEIGHT) continue;
			for (int col = 0; col < 3; col++) {
				int px = sx + col;
				if (px < 0 || px >= TFT_WIDTH) continue;
				int bit = 14 - (row * 3 + col);
				if ((glyph >> bit) & 1) {
					tft_draw_pixel(px, py, color);
				}
			}
		}
		sx += 4;
	}
}

static inline void hud_draw_text_fmt(int sx, int sy, color_t color, const char *fmt, ...)
{
	char buf[48];
	va_list args;
	va_start(args, fmt);
	vsnprintf(buf, sizeof(buf), fmt, args);
	va_end(args);
	hud_draw_text(sx, sy, color, buf);
}
